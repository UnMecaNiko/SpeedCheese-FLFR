# Keil uVision project Robot_Velocista.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Robot_Velocista +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\Include\Serial;.\Include\PLL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c main.h Interrupt.h Interrupt.c tim_pwm.h tim_pwm.c
    ./Include/PLL/: PLL.c PLL.h
  group Serial
    ./Include/Serial/: UART_STM32F411.c UART_STM32F411.h
  group QTR
    ./: QTR_8RC.h QTR_8RC.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
